## Patches/rtl8723bs_bt/Config.in
```kconfig
config BR2_PACKAGE_RTL8723BS_BT
	bool "rtl8723bs_bt"
	help
	  rtl8723bs bt driver

          https://github.com/lwfinger/rtl8723bs_bt
```
